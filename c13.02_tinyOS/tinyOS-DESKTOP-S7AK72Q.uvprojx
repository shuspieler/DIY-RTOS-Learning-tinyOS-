# Keil uVision project tinyOS-DESKTOP-S7AK72Q.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: tinyOS
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./Source/: main.c switch.c tinyOS.h tLib.h tBitmap.c tConfig.h tList.c tTask.c tTime.c tCpu.c app.c tEvent.h tEvent.c tTask.h tSem.h tSem.c tMbox.h tMbox.c tMemBlock.h tMeBlock.c tFlagGroup.c tFlagGroup.h tMutex.h tMutex.c tTimer.c tTimer.h tHooks.c tHooks.h
  group ::Device
    RTE/Device/STM32F103RB/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
