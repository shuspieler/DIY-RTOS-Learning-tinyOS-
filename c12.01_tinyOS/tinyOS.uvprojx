# Keil uVision project tinyOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: tinyOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Source/: main.c switch.c tinyOS.h tLib.h tBitmap.c tConfig.h tList.c tTask.c tTime.c tCpu.c app.c tEvent.h tEvent.c tTask.h tSem.h tSem.c tMbox.h tMbox.c tMemBlock.h tMeBlock.c tFlagGroup.c tFlagGroup.h tMutex.h tMutex.c tTimer.c tTimer.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
