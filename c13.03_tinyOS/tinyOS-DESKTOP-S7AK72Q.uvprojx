# Keil uVision project tinyOS-DESKTOP-S7AK72Q.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tinyOS
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./Source/: app.c main.c switch.c tBitmap.c tCpu.c tEvent.c tFlagGroup.c tHooks.c tList.c tMbox.c tMeBlock.c tMutex.c tSem.c tTask.c tTime.c tTimer.c
  group ::Device
    RTE/Device/STM32F103RB/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
