# Keil uVision project tinyOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tinyOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./Source/: app.c main.c switch.c tBitmap.c tCpu.c tEvent.c tFlagGroup.c tHooks.c tList.c tMbox.c tMeBlock.c tMutex.c tSem.c tTask.c tTime.c tTimer.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
